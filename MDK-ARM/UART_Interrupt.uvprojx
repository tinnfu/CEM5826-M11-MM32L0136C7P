# Keil uVision project UART_Interrupt.uvprojx, settings and files
target CEM5826-M11 (6220000::V6.22::ARMCLANG)
  device: MM32L0136C7P MindMotion
  pack: MindMotion.MM32L0130_DFP.1.1.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: UART_Interrupt +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\CEM5826-M11;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32L0130\HAL_Lib\Inc;..\..\Device\MM32L0130\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../: main.c mm32l0130_it.c uart_interrupt.c platform.c slcd_basic.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../Device/MM32L0130/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crcpoly.c hal_dbg.c hal_dma.c hal_dmamux.c hal_exti.c hal_fgpio.c hal_flash.c hal_gpio.c hal_i2c.c hal_irm.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_slcd.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_wwdg.c
  group STARTUP
    ../../Device/MM32L0130/Source/KEIL_StartAsm/: startup_mm32l0130_keil.s
    ../../Device/MM32L0130/Source/: system_mm32l0130.c
