# Keil uVision project CEM5826-M11.uvprojx, settings and files
target CEM5826-M11 (6220000::V6.22::ARMCLANG)
  device: MM32L0136C7P MindMotion
  pack: MindMotion.MM32L0130_DFP.1.1.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: CEM5826-M11 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\CEM5826-M11;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32L0130\HAL_Lib\Inc;..\..\Device\MM32L0130\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../: main.c platform.c slcd.c uart.c mm32l0130_it.c
  group HAL_LIB
    ../../Device/MM32L0130/HAL_Lib/Src/: hal_slcd.c hal_uart.c hal_rcc.c hal_pwr.c hal_gpio.c
  group STARTUP
    ../../Device/MM32L0130/Source/: system_mm32l0130.c
    ../../Device/MM32L0130/Source/KEIL_StartAsm/: startup_mm32l0130_keil.s
